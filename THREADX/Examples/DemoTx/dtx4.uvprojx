# Keil uVision project dtx4.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: M55_HP Alif Semiconductor
  pack: AlifSemiconductor.CONCERTO.0.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: dtx4
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: TX_SINGLE_MODE_SECURE
  asm define: TX_SINGLE_MODE_SECURE
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\M55_HP\M55_HP.sct
software components: CMSIS:CORE 5.4.0, RTOS:Kernel Port 6.1.3, RTOS:Sample App 6.1.3, Device:Startup 1.0.0
